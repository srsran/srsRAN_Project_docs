options:
  parameters:
    generate_options: no_gui
    id: geo_ntn_channel_emulator
    output_language: python
    run_options: run
    title: GEO NTN Channel Emulator
  states: {}

blocks:
- name: channel_delay_samples
  id: variable
  parameters:
    value: int(samp_rate*1e-6*channel_delay_us)
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: channel_delay_samples
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: channel_delay_samples
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channel_delay_us
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: note_0
  id: note
  parameters:
    note: 'DL: SAT -> UE Link'
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: 'UL: UE -> SAT Link'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: eng_float
    value: 5.76e6
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_delay_0, '0', zeromq_rep_sink_0, '0']
- [blocks_delay_0_0, '0', zeromq_rep_sink_0_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0_0, '0', blocks_delay_0_0, '0']
- [zeromq_req_source_0, '0', blocks_throttle_0, '0']
- [zeromq_req_source_0_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
